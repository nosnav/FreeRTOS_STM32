# Keil uVision project STM32F4.uvprojx, settings and files
target STM32F4 Discovery (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.7.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4 +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\User;..\Library;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\Include;..\Drivers\STM32F4xx_StdPeriph_Driver\inc;..\FreeRTOS_V9\include;..\FreeRTOS_V9\portable\RVDS\ARM_CM4F
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c stm32f4xx_it.c
  group CMSIS
    ../User/: system_stm32f4xx.c
  group Startup
    ../Drivers/CMSIS/Device/Source/arm/: startup_stm32f40xx.s
  group StdPeriph_Driver
    ../Drivers/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c
  group FreeRTOS
    ../FreeRTOS_V9/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group portable
    ../FreeRTOS_V9/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS_V9/portable/MemMang/: heap_4.c
